# Keil uVision project bootlloader.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootlloader +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Drive\FirmwareMange;..\Drive\STMFLASH;..\Drive\Communcation;D:\Keil_v5\ARM\Pack\ARM\CMSIS\5.0.0\CMSIS\Include;..\User;..\Drive\CRC32;..\Drive\FirmwareManage
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c startup_stm32f10x_hd.s ActionProcess.c config.h
  group Drive
    ../Drive/STMFLASH/: stmflash.c
    ../Drive/Communcation/: Communcation.c
    ../Drive/CRC32/: CRC32.c
    ../Drive/FirmwareManage/: FirmwareManage.c
  group System
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
